# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__FPU_PRESENT,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\CAN;..\HARDWARE\PID;..\HARDWARE\RemoteControl;..\HARDWARE\RC;..\FreeRTOS;..\TASK\chassis_task;..\TASK\gimbal_task;..\Judge\get_judge_measure;..\Judge\Judge_task;..\Judge\judgement_info;..\Judge\protocol;..\detect_task;..\math\Ramp;..\TASK\shoot_task;..\Judge\UI_task;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;..\TASK\pc_task;..\mpu;..\HARDWARE\iwdg;..\math\Kalaman
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/RemoteControl/: RemoteControl.c
    ../HARDWARE/RC/: rc.c
    ../HARDWARE/iwdg/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart1.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_i2c.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_wwdg.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c cmsis_os.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group MPU
    ../mpu/: accelerometer_calibration.c arm_cortexM4lf_math.lib BSP_Flash.c BSP_MPU9250_Init.c Filter_Control.c IMUTask.c mpu_delay.c MPU_SPI_Init.c MPU_TIME_Init.c
  group TASK
    ../TASK/chassis_task/: chassis_task.c
    ../TASK/gimbal_task/: gimbal_task.c
    ../TASK/shoot_task/: shoot_task.c
    ../TASK/pc_task/: TX2.c
  group Judge
    ../Judge/Judge_task/: Judge_task.c
    ../Judge/judgement_info/: judgement_info.c
    ../Judge/protocol/: protocol.c
    ../Judge/get_judge_measure/: get_judge_measure.c
    ../Judge/UI_task/: RM_Client_UI.c
  group detect_task
    ../detect_task/: detect_task.c
  group MATH
    ../math/Ramp/: Ramp_Control.c
    ../math/Kalaman/: Kalaman.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
